# Keil uVision project stm32f407ve.uvprojx, settings and files
target Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: fw_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F407xx;USE_HAL_DRIVER
  c include: ..\..\framework\include;..\..\framework\components\protocol\include;..\..\framework\app\include;..\..\framework\ports\stm32f4\include;..\..\framework\ports\freertos\include;..\..\framework\boards\stm32f407ve;..\..\projects\stm32f407\config;..\..\third_party\hal-src\Inc;..\..\third_party\device-src\Include;..\..\third_party\cmsis-src\CMSIS\Core\Include;..\..\third_party\freertos-src\include;..\..\third_party\freertos-src\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\projects\stm32f407\stm32f407ve.sct
  group framework/core
    ../../framework/core/: io.c ring.c
  group framework/components/protocol
    ../../framework/components/protocol/: protocol.c
  group framework/app
    ../../framework/app/: demo_app.c
    ../../framework/app/assets/: avatar_128x160.c
  group framework/boards/stm32f407ve
    ../../framework/boards/stm32f407ve/: board.c
  group framework/ports
    ../../framework/ports/stm32f4/: gpio.c uart.c st7735.c
    ../../framework/ports/freertos/: runtime.c
  group third_party/FreeRTOS
    ../../third_party/freertos-src/: tasks.c queue.c list.c
    ../../third_party/freertos-src/portable/RVDS/ARM_CM4F/: port.c
  group third_party/HAL
    ../../third_party/hal-src/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c
  group third_party/Device
    ../../third_party/device-src/Source/Templates/: system_stm32f4xx.c
  group third_party/Startup
    ../../third_party/device-src/Source/Templates/arm/: startup_stm32f407xx.s
  group project/stm32f407
    ../../projects/stm32f407/: main.c interrupts.c
